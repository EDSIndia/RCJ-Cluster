# IAR project Backup (1) of LCD_Cluster_G0_Rev0.ewp, settings and files
configuration LCD_Cluster_G0_Rev0 (ARM, debug)
  General.OGChipSelectEditMenu: STM32G0B1CB ST STM32G0B1CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32G0B1xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32G0xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LCD_Cluster_G0_Rev0.hex
  ILINK.IlinkOutputFile: LCD_Cluster_G0_Rev0.out
  ILINK.IlinkIcfFile: stm32g0b1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../Core/Src/: README.txt
  group Application/EWARM
    ./: startup_stm32g0b1xx.s
  group Application/User/Core
    ../Core/Src/: adc.c App_RAM.c Display_Driver.c fdcan.c FDCAN_DRIVER.c main.c Misc_Functions.c ONE_WIRE_COMM.c STM32_Config.c stm32g0xx_hal_msp.c stm32g0xx_it.c VOLTAGE_CAL.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_adc.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_exti.c stm32g0xx_hal_fdcan.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_iwdg.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_adc.c stm32g0xx_ll_crs.c stm32g0xx_ll_dma.c stm32g0xx_ll_exti.c stm32g0xx_ll_gpio.c stm32g0xx_ll_rcc.c stm32g0xx_ll_tim.c stm32g0xx_ll_utils.c
